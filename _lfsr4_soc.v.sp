$ Spice netlist generated by v2lvs
$ v2018.4_17.10    Wed Oct 3 17:08:53 PDT 2018
*.BUSDELIMITER [

.SUBCKT lfsr4 clk rst data_out[3] data_out[2] data_out[1] data_out[0]
XFE_PHC1_rst BUFFD1BWP7T $PINS I=rst Z=FE_PHN1_rst
XFE_PHC0_rst CKBD0BWP7T $PINS I=FE_PHN1_rst Z=FE_PHN0_rst
Xsreg_reg[1] DFSNQD1BWP7T $PINS CP=clk D=n_1 Q=data_out[0] SDN=n_0
Xg16__8780 CKXOR2D0BWP7T $PINS A1=data_out[2] A2=data_out[3] Z=n_1
Xsreg_reg[4] DFCNQD1BWP7T $PINS CDN=n_0 CP=clk D=data_out[2] Q=data_out[3]
Xsreg_reg[3] DFCNQD1BWP7T $PINS CDN=n_0 CP=clk D=data_out[1] Q=data_out[2]
Xsreg_reg[2] DFCNQD1BWP7T $PINS CDN=n_0 CP=clk D=data_out[0] Q=data_out[1]
Xg20 INVD0BWP7T $PINS I=FE_PHN0_rst ZN=n_0
.ENDS
